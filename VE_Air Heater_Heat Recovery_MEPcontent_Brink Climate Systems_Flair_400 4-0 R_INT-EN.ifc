Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-09-19T12:31:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 19 12:31:34 2018 * Host: B3ROBRAWR2791 * Database: C:\Users\CS\AppData\Local\Temp\{C0A20E3E-474C-4EEF-851C-169BB3A37175}\ifc * Database version: 5507 * Database creation date: Wed Sep 19 12:31:32 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 19 12:31:32 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 19 12:31:32 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcAirToAirHeatRecovery: 400 4-0 R, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN:400 4-0 R:1297938
In: V00
Type - Material: Color RGB 241-240-234, Color RGB 152-158-161
Type - Dimensions - Connection Diameter: 180 mm; Depth: 560 mm; Diameter: 32 mm; Height: 650 mm; Width: 750 mm
Type - Identity Data - Article Type: 400 4-0 R; Base Family Version: 11.20; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 4.0; ETIM Article Class: EC011285; Family Version: 11.20; GLN: 8714253038933; Manufacturer: Brink Climate Systems; Manufacturer URL: https://www.brinkclimatesystems.nl/en-us/international/home/docsearch; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: 400 4-0 R; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Revit Version: 2017; Type Name: 400 4-0 R; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Color Body: Color RGB 241-240-234; Color Door: Color RGB 152-158-161; Glass: Color RGB 218-227-224
Type - Other - Category: Mechanical Equipment; Connection Inner Radius: 87 mm; Connection Radius: 89 mm; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN; Flange Radius: 100 mm
Type - Text - Article Description: Heat recovery unit; GTIN: 8718391209859; Manufacturer Art. No.: 431001; Product Line: Brink Climate Systems
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 3.36507 m2; Volume: 0.565213 m3
Electrical - Loads - Connection Voltage: 230 V; Nominal Current: 0 V; Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Power,Exhaust Air,Supply Air,Return Air,Sanitary
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Return Air Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN: 400 4-0 R; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN: 400 4-0 R; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN: 400 4-0 R; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Flair_400_Right_INT-EN: 400 4-0 R; Wall Offset: 8 mm
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Mounting Bracket: yes; Service Area: no
